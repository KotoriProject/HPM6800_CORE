File: 03DDR.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: 添加库 添加网络类
Parts:
- added U1: HPM6880IBD1, HPM_footprints:BGA_417, symbol HPM6800:HPM6880IBD1
