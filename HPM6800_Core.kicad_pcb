File: HPM6800_Core.kicad_pcb (KiCad board)
At the start: 4 copper layers, 0 parts

Commit message: 添加库 添加网络类
Parts:
- added U1: HPM6880IBD1, HPM_footprints:BGA_417, F.Cu at (92.7, 59.7)
